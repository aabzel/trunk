/*
 * can_error.c
 *
 *  Created on: May 13, 2025
 *      Author: karbovskiy
 */



/* ---------------------------------------------------------------------------*/
/* Includes ------------------------------------------------------------------*/
/* ---------------------------------------------------------------------------*/

#include "main.h"
#include "can.h"
#include "can_tx.h"
#include "can_error.h"



/* ---------------------------------------------------------------------------*/
/* External variables --------------------------------------------------------*/
/* ---------------------------------------------------------------------------*/

/* ---------------------------------------------------------------------------*/
/* Private define ------------------------------------------------------------*/
/* ---------------------------------------------------------------------------*/

/* ---------------------------------------------------------------------------*/
/* Private typedef -----------------------------------------------------------*/
/* ---------------------------------------------------------------------------*/

typedef struct canNode_t canNode_t;



/* ---------------------------------------------------------------------------*/
/* Private macro -------------------------------------------------------------*/
/* ---------------------------------------------------------------------------*/

/* ---------------------------------------------------------------------------*/
/* Private constants ---------------------------------------------------------*/
/* ---------------------------------------------------------------------------*/

/* ---------------------------------------------------------------------------*/
/* Private variables ---------------------------------------------------------*/
/* ---------------------------------------------------------------------------*/

/* ---------------------------------------------------------------------------*/
/* Private function prototypes -----------------------------------------------*/
/* ---------------------------------------------------------------------------*/

/* ---------------------------------------------------------------------------*/
/* Public Functions ----------------------------------------------------------*/
/* ---------------------------------------------------------------------------*/

void CAN_ErrorCallback( FLEXCAN_HandleType *hcan, FLEXCAN_ErrorInfoType *pErrorInfo )
{
	canNode_t* pNode = Get_CAN_Node( hcan );
	(void) pNode;

	CAN_ESR1_TypeDef can_err = {
		.bitwise = pErrorInfo->u32ESR1Value
	};

	if ( 1U == can_err.BIT1ERR )
	{

	} //if

	if ( 1U == can_err.BIT0ERR )
	{

	} //if

	if ( 1U == can_err.ERROVR )
	{

	} //if

	if ( 1U == can_err.ACKERR )
	{

	} //if

	if ( 1U == can_err.CRCERR || 1U == can_err.FRMERR || 1U == can_err.STFERR )
	{

	} //if

	if ( 1U == can_err.TXWRN || 1U == can_err.RXWRN )
	{

	} //if

} //CAN_ErrorCallback()



/* ---------------------------------------------------------------------------*/
/* Private Functions ---------------------------------------------------------*/
/* ---------------------------------------------------------------------------*/
