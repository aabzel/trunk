## source/sensitivity/incremental_encoder/Kconfig
```kconfig
config INCREMENTAL_ENCODER
    bool "Enable use of the INCREMENTAL_ENCODER drivers"
```
